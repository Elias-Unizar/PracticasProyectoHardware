# Keil uVision project blink_lpc.uvproj, settings and files
target LPC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: blink_lpc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC2105_simulador
  c include: ../../src;../src_lpc;../../src/hal_h;../../src/drv_;../../src/svc_;../../src/runtime;../../src/app;../../src/tests
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Comun
    ../../src/runtime/: rt_fifo.c rt_fifo.h rt_GE.c rt_GE.h
    ../../src/: env.h
  group Dependientes
    ../src_lpc/: board_lpc.h hal_gpio_lpc.c hal_tiempo_lpc.c reserva_gpio_lpc2105.h hal_consumo_lpc.c hal_ext_int_lpc.c hal_watchdog_lpc.c hal_irq_lpc.c
  group Inicio
    ../src_lpc/: Startup.s
  group Drivers
    ../../src/drv_/: drv_consumo.c drv_consumo.h drv_leds.c drv_leds.h drv_monitor.c drv_monitor.h drv_tiempo.c drv_tiempo.h board.h drv_botones.c drv_botones.h drv_watchdog.c drv_watchdog.h drv_sc.c drv_sc.h
  group Services
    ../../src/svc_/: svc_alarma.h svc_alarma.c svc_diagnostico.c svc_diagnostico.h svc_GE.h
  group Hal_H
    ../../src/hal_h/: hal_consumo.h hal_gpio.h hal_tiempo.h hal_ext_int.h hal_watchdog.h hal_irq.h
  group Tests
    ../../src/tests/: main-test.c test_consumo.c test_fifo.c test_led.c test_consumo.h test_fifo.h test_led.h test_tiempo.c test_tiempo.h test_svc_alarma.c test_svc_alarma.h test_svc_diagnostico.c test_svc_diagnostico.h test_svc_GE.c test_svc_GE.h test_botones.h test_botones.c test_watchdog.c test_watchdog.h
  group app
    ../../src/app/: main.c
