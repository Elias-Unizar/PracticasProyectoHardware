# Keil uVision project neuron_q12.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: neuron_q12
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group inicio
    ./: Startup.s
  group fuentes
    ./: main.c dense_q12.h dense_q12_stubs.c dense_layer_q12_ARM.s dense_layer_q12_ARM_C.s dense_layer_q12_THB.s neuron_q12_ARM.s neuron_q12_THB.s codigoARMOptimizado.s
