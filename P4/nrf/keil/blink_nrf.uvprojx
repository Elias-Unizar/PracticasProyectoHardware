# Keil uVision project blink_nrf.uvprojx, settings and files
target nRF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: blink_nrf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: ../src_nrf;../../src;../../src/drv_;../../src/hal_h;../../src/svc_;../../src/tests;../../src/runtime;../../src/app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group Source Comun
    ../../src/: env.h
    ../../src/runtime/: rt_fifo.c rt_fifo.h rt_GE.c rt_GE.h
  group Dependientes
    ../src_nrf/: hal_gpio_nrf.c hal_tiempo_nrf.c board_nrf52840dk.h board_nrf52840_dongle.h hal_consumo_nrf.c hal_ext_int_nrf.c hal_watchdog_nrf.c hal_irq_nrf.c
  group Hal_H
    ../../src/hal_h/: hal_consumo.h hal_gpio.h hal_tiempo.h hal_ext_int.h hal_irq.h hal_watchdog.h
  group Drivers
    ../../src/drv_/: drv_consumo.c drv_consumo.h drv_leds.c drv_leds.h drv_monitor.c drv_monitor.h drv_tiempo.c drv_tiempo.h board.h drv_botones.c drv_botones.h drv_sc.c drv_sc.h drv_watchdog.c drv_watchdog.h
  group Services
    ../../src/svc_/: svc_alarma.c svc_alarma.h svc_diagnostico.c svc_diagnostico.h svc_GE.c svc_GE.h
  group Tests
    ../../src/tests/: main-test.c test_botones.c test_botones.h test_consumo.c test_consumo.h test_fifo.c test_fifo.h test_led.c test_led.h test_svc_alarma.c test_svc_alarma.h test_svc_diagnostico.c test_svc_diagnostico.h test_svc_GE.c test_svc_GE.h test_tiempo.c test_tiempo.h test_watchdog.c test_watchdog.h
  group app
    ../../src/app/: main.c funcionesCallbackJuego.c funcionesCallBackJuego.h
software components: CMSIS:CORE 5.3.0, Device:Startup 8.44.1
